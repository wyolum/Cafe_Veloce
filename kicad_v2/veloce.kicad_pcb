# Repository wyolum/Cafe_Veloce

File README.md:

# Cafe_Veloce
Controller board for eBicycle lighting

**Renders**

License
-------
[CERN Open Hardware Licence v1.2 ]

[CERN Open Hardware Licence v1.2 ]:http://www.ohwr.org/attachments/2388/cern_ohl_v_1_2.txt

## KiCad design kicad_v2/veloce.kicad_pcb

Parts:
D17, D18, D19: LED; LED_0805_2012Metric
G1: Logo_Veloce; logo_CV_v2_silk
G2: Logo_Veloce; logo_VR_v2_mask
G3: Logo_Veloce; logo_CV_v2_silk2
G4: Logo_Veloce; logo_CV_v2_mask2
G5: LOGO_WL; logo_butterfly_silk_15x12
G6: LOGO_WL; logo_butterfly_mask_15x12
G7: Logo_OSHW; Logo_OSHW-11.4x12mm_SilkScreen
G8: Logo_Wyolum; logo_wyolum_silk_20x8
G9: Logo_Wyolum; logo_wyolum_mask_20x8
H1, H2, H3, H4: Screw; MountingHole_3.2mmx6.4mm_M3_Pad_Via
J9: PWR; TerminalBlock_Wurth_1377-16_Horizontal
J17: USB_A_stacked; USB_A_Wuerth_61400826021_Horizontal_Stacked
J20: Inputs; TerminalBlock_Wurth_1377-16_Horizontal
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: Pull_Up_Dn; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_THT
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14: CONN_1; TestPoint_THTPad_D3.0mm_Drill1.5mm
PS2: LM2569; 5VReg_module_LM2596
R25, R26, R27, R28, R29, R30, R31, R32, R33: 10k; r_0805_THT
R46: 510E; R_0805_2012Metric
R47: 1k8; R_0805_2012Metric
R48: 5k6; R_0805_2012Metric
U1: Adafruit_HUZZAH_ESP32_breakout_physical; Adafruit_HUZZAH_ESP32_breakout_FIXED

Connections:
/3V3: JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP9.1 (A), U1.14 (3V3)
/5V: J9.7, J9.8, J9.9, J17.1 (VBUS), J17.5 (VBUS), P7.1, P8.1, P9.1, PS2.VO, R46.1, U1.16 (VBAT)
/12V: J9.4, J9.5, J9.6, P4.1, P5.1, P6.1, PS2.VIN, R47.1; also elsewhere on the board
/72V: J9.1, J9.2, J9.3, P1.1, P2.1, P3.1, R48.1
/BRAKE: J9.16, R33.2, U1.18 (GPIO2)
/GND: D17.1 (K), D18.1 (K), D19.1 (K), J9.10, J9.11, J9.12, J9.13, J9.14, J9.15, J17.4 (GND), J17.8 (GND), J17.9 (Shield), J20.2, J20.4, J20.6, J20.8, J20.10, J20.12, J20.14, J20.16, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B), P10.1, P11.1, P12.1, P13.1, P14.1, PS2.GND, U1.15 (GND); also elsewhere on the board
/IN1: J20.15, R25.2, U1.26 (GPIO21)
/IN2: J20.13, R26.2, U1.25 (GPIO19)
/IN3: J20.11, R27.2, U1.24 (GPIO18)
/IN4: J20.9, R28.2, U1.23 (GPIO5)
/IN5: J20.7, R29.2, U1.22 (GPIO17)
/IN6: J20.5, R30.2, U1.21 (GPIO16)
/IN7: J20.3, R31.2, U1.20 (GPIO4)
/IN8: J20.1, R32.2, U1.19 (GPIO0)
/OUT1: U1.6 (GPIO32); also elsewhere on the board
/OUT2: U1.7 (GPIO33); also elsewhere on the board
/OUT3: U1.8 (GPIO25); also elsewhere on the board
/OUT4: U1.9 (GPIO26); also elsewhere on the board
/OUT5: U1.10 (GPIO27); also elsewhere on the board
/OUT6: U1.11 (GPIO14); also elsewhere on the board
/OUT7: U1.12 (GPIO12); also elsewhere on the board
/OUT8: U1.13 (GPIO13); also elsewhere on the board
unnamed: D17.2 (A), R46.2
unnamed: D18.2 (A), R47.2
unnamed: D19.2 (A), R48.2
unnamed: JP1.2 (C), R33.1
unnamed: JP2.2 (C), R25.1
unnamed: JP3.2 (C), R26.1
unnamed: JP4.2 (C), R27.1
unnamed: JP5.2 (C), R28.1
unnamed: JP6.2 (C), R29.1
unnamed: JP7.2 (C), R30.1
unnamed: JP8.2 (C), R31.1
unnamed: JP9.2 (C), R32.1

Notes on the sheet:
72V
GND
12V
NOTE : This block allows setting each input with pull up or pull down

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: B220A-13-F; D_SMA
D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_0805_2012Metric
J1, J2, J3, J4, J5, J6, J7, J8: OUT; TerminalBlock_Wurth_1377-2_Horizontal
Q1, Q3: FQD11P06TM; TO-252-3_TabPin2
Q2, Q4, Q6, Q8, Q10, Q12, Q14, Q16: RUM001L02T2CL; SOT-723
Q5, Q7, Q9, Q11, Q13, Q15: ZXMP7A17K; TO-252-3_TabPin2
R1, R3, R4, R6, R7, R9, R10, R12, R13, R15, R16, R18, R19, R21, R22, R24: 12k; R_0805_2012Metric
R2, R5, R8, R11, R14, R17, R20, R23: 0E; R_0805_2012Metric
R38, R39, R40, R41, R42, R43, R44, R45: 1k; R_0805_2012Metric

Connections:
/12V: Q1.3 (S), Q3.3 (S), Q5.3 (S), Q7.3 (S), Q9.3 (S), Q11.3 (S), Q13.3 (S), Q15.3 (S), R1.2, R4.2, R7.2, R10.2, R13.2, R16.2, R19.2, R22.2; also elsewhere on the board
/GND: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, Q2.2 (S), Q4.2 (S), Q6.2 (S), Q8.2 (S), Q10.2 (S), Q12.2 (S), Q14.2 (S), Q16.2 (S), R3.1, R6.1, R9.1, R12.1, R15.1, R18.1, R21.1, R24.1; also elsewhere on the board
/MOSFETS/OP1: D1.1 (K), J1.1, Q1.2 (D), R38.2
/MOSFETS/OP2: D2.1 (K), J2.1, Q3.2 (D), R39.2
/MOSFETS/OP3: D3.1 (K), J3.1, Q5.2 (D), R40.2
/MOSFETS/OP4: D4.1 (K), J4.1, Q7.2 (D), R41.2
/MOSFETS/OP5: D5.1 (K), J5.1, Q9.2 (D), R42.2
/MOSFETS/OP6: D6.1 (K), J6.1, Q11.2 (D), R43.2
/MOSFETS/OP7: D7.1 (K), J7.1, Q13.2 (D), R44.2
/MOSFETS/OP8: D8.1 (K), J8.1, Q15.2 (D), R45.2
/OUT1: Q2.1 (G), R3.2; also elsewhere on the board
/OUT2: Q4.1 (G), R6.2; also elsewhere on the board
/OUT3: Q6.1 (G), R9.2; also elsewhere on the board
/OUT4: Q8.1 (G), R12.2; also elsewhere on the board
/OUT5: Q10.1 (G), R15.2; also elsewhere on the board
/OUT6: Q12.1 (G), R18.2; also elsewhere on the board
/OUT7: Q14.1 (G), R21.2; also elsewhere on the board
/OUT8: Q16.1 (G), R24.2; also elsewhere on the board
unnamed: D9.2 (A), R38.1
unnamed: D10.2 (A), R39.1
unnamed: D11.2 (A), R40.1
unnamed: D12.2 (A), R41.1
unnamed: D13.2 (A), R42.1
unnamed: D14.2 (A), R43.1
unnamed: D15.2 (A), R44.1
unnamed: D16.2 (A), R45.1
unnamed: Q1.1 (G), R1.1, R2.2
unnamed: Q2.3 (D), R2.1
unnamed: Q3.1 (G), R4.1, R5.2
unnamed: Q4.3 (D), R5.1
unnamed: Q5.1 (G), R7.1, R8.2
unnamed: Q6.3 (D), R8.1
unnamed: Q7.1 (G), R10.1, R11.2
unnamed: Q8.3 (D), R11.1
unnamed: Q9.1 (G), R13.1, R14.2
unnamed: Q10.3 (D), R14.1
unnamed: Q11.1 (G), R16.1, R17.2
unnamed: Q12.3 (D), R17.1
unnamed: Q13.1 (G), R19.1, R20.2
unnamed: Q14.3 (D), R20.1
unnamed: Q15.1 (G), R22.1, R23.2
unnamed: Q16.3 (D), R23.1

Notes on the sheet:
High Power, upto 5 Amps
HEAD LIGHT
TAIL LIGHT
LEFT IND
For 48V, use 36k For 24V, use 12k For 12V, use 0E
SPARE
Low Power, upto 1 Amps
BRAKE LIGHT
RIGHT IND

Board: 2 copper layers, 116.0 x 105.0 mm, 156 parts (16 on the bottom side), 66 nets.

Other parts of the board:
kibuzzard-61BB7D75: G***; label_brk
kibuzzard-61BB7E28, kibuzzard-614E1DC4: G***; label_12V
kibuzzard-61BB7E88, kibuzzard-614E1DE5: G***; label_72V
kibuzzard-61BC3C7D: G***; label_buck_output
kibuzzard-61BC3C42: G***; label_buck_input
kibuzzard-61BC84E3: G***; label_5V_USB
kibuzzard-61BC4209, kibuzzard-61BC4209#2: G***; label_GND
kibuzzard-614E1E36, kibuzzard-614E1E36#2: G***; label_5V
kibuzzard-614E18A2: G***; label_OUT5
kibuzzard-614E18AA: G***; label_OUT6
kibuzzard-614E18B2: G***; label_OUT7
kibuzzard-614E18BA: G***; label_OUT8
kibuzzard-614E19A5: G***; label_IN2
kibuzzard-614E19AF: G***; label_IN3
kibuzzard-614E19B6: G***; label_IN4
kibuzzard-614E19C0: G***; label_IN5
kibuzzard-614E19C8: G***; label_IN6
kibuzzard-614E19D4: G***; label_IN7
kibuzzard-614E19DD: G***; label_IN8
kibuzzard-614E188E: G***; label_OUT3
kibuzzard-614E196C: G***; label_IN1
kibuzzard-614E1815: G***; label_OUT1
kibuzzard-614E1883: G***; label_OUT2
kibuzzard-614E1899: G***; label_OUT4

File kicad_v2/gerber/veloce_v2_JLCpcb/veloce_BOM_JLCSMT_v2.xlsx:

Comment | Designator | Footprint | JLCPCB Part #（optional）
B220A-13-F | D8,D7,D6,D5,D4,D3,D2,D1 | D_SMA | C110481
LED | D19,D18,D17,D16,D15,D14,D13,D12,D11,D10,D9 | LED_0805_2012Metric | C397047
FQD11P06TM | Q3,Q1 | TO-252-3_TabPin2
ZXMP7A17K | Q15,Q13,Q11,Q9,Q7,Q5 | TO-252-3_TabPin2
RUM001L02T2CL | Q16,Q14,Q12,Q10,Q8,Q6,Q4,Q2 | SOT-723 | C253528
0E | R23,R20,R17,R14,R11,R8,R5,R2 | R_0805_2012Metric | C25275
12k | R24,R22,R21,R19,R18,R16,R15,R13,R12,R10,R9,R7,R6,R4,R3,R1 | R_0805_2012Metric | C25616
10k | R32,R31,R30,R29,R28,R27,R26,R25,R33 | r_0805_THT | C25612
1k | R45,R44,R43,R42,R41,R40,R39,R38 | R_0805_2012Metric | C25623
510E | R46 | R_0805_2012Metric | C25317
1k8 | R47 | R_0805_2012Metric | C26016
5k6 | R48 | R_0805_2012Metric | C26024

## KiCad design kicad/veloce.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: B220A-13-F; D_SMB
G1: Logo_Veloce; VR_logo4
G2: Logo_Veloce; VR_logo5
G3: Logo_Veloce; VR_logo2
G4: Logo_Veloce; VR_logo3
G5: LOGO_WL; logo_butterfly_silk_15x12
G6: LOGO_WL; logo_butterfly_mask_15x12
G7: Logo_OSHW; Logo_OSHW-11.4x12mm_SilkScreen
G8: Logo_Wyolum; logo_wyolum_silk_20x8
G9: Logo_Wyolum; logo_wyolum_mask_20x8
H1, H2, H3, H4: Screw; MountingHole_3.2mm_M3_Pad_Via
J1, J2, J3, J4, J5, J6, J7, J8: OUT; TerminalBlock_Wurth_1377-2_Horizontal
J9: PWR; TerminalBlock_Wurth_1377-16_Horizontal
J17: USB_A_stacked; USB_A_Wuerth_61400826021_Horizontal_Stacked
J18, J19: USB_C_Receptacle_USB2.0; USB_C_GCT_USB4085-GF-A_REVA
J20: Inputs; TerminalBlock_Wurth_1377-16_Horizontal
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: Pull_Up_Dn; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_THT
Q1, Q2: IRLR7843TRPBF; MOSFET_D_PAK
Q3, Q4, Q5, Q6, Q7, Q8: AO3400A; SOT-23
R1, R2, R5, R6, R9, R10, R13, R14: 100E; R_0805_2012Metric
R3, R4, R7, R8, R11, R12, R15, R16: 10k; R_0805_2012Metric
R17, R18, R19, R20: 22k; r_0805_THT
R21, R22, R23, R24, R25, R26, R27, R28, R29: 10k; r_0805_THT
U1: Adafruit_HUZZAH_ESP32_breakout_physical; Adafruit_HUZZAH_ESP32_breakout_sparepads

Connections:
/3V3: JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP9.1 (A), U1.14 (3V3)
/5V: J9.6, J9.7, J17.1 (VBUS), J17.5 (VBUS), J18.A4 (VBUS), J18.A9 (VBUS), J18.B4 (VBUS), J18.B9 (VBUS), J19.A4 (VBUS), J19.A9 (VBUS), J19.B4 (VBUS), J19.B9 (VBUS), R17.1, R18.1, R19.1, R20.1, U1.16 (VBAT)
/12V: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.4, J9.5
/72V: J9.1, J9.2, J9.3
/BRAKE: J9.16, R21.2, U1.18 (GPIO2)
/GND: J9.8, J9.9, J9.10, J9.11, J9.12, J9.13, J9.14, J9.15, J17.4 (GND), J17.8 (GND), J17.9 (Shield), J18.A1 (GND), J18.A12 (GND), J18.B1 (GND), J18.B12 (GND), J18.S1 (SHIELD), J19.A1 (GND), J19.A12 (GND), J19.B1 (GND), J19.B12 (GND), J19.S1 (SHIELD), J20.2, J20.4, J20.6, J20.8, J20.10, J20.12, J20.14, J20.16, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R3.1, R4.1, R7.1, R8.1, R11.1, R12.1, R15.1, R16.1, U1.15 (GND)
/IN1: J20.15, R22.2, U1.26 (GPIO21)
/IN2: J20.13, R23.2, U1.25 (GPIO19)
/IN3: J20.11, R24.2, U1.24 (GPIO18)
/IN4: J20.9, R25.2, U1.23 (GPIO5)
/IN5: J20.7, R26.2, U1.22 (GPIO17)
/IN6: J20.5, R27.2, U1.21 (GPIO16)
/IN7: J20.3, R28.2, U1.20 (GPIO4)
/IN8: J20.1, R29.2, U1.19 (GPIO0)
/OP1: D1.2 (A), J1.2, Q1.3 (D)
/OP2: D2.2 (A), J2.2, Q2.3 (D)
/OP3: D3.2 (A), J3.2, Q3.3 (D)
/OP4: D4.2 (A), J4.2, Q4.3 (D)
/OP5: D5.2 (A), J5.2, Q5.3 (D)
/OP6: D6.2 (A), J6.2, Q6.3 (D)
/OP7: D7.2 (A), J7.2, Q7.3 (D)
/OP8: D8.2 (A), J8.2, Q8.3 (D)
/OUT1: R1.2, R3.2, U1.6 (GPIO32)
/OUT2: R2.2, R4.2, U1.7 (GPIO33)
/OUT3: R5.2, R7.2, U1.8 (GPIO25)
/OUT4: R6.2, R8.2, U1.9 (GPIO26)
/OUT5: R9.2, R11.2, U1.10 (GPIO27)
/OUT6: R10.2, R12.2, U1.11 (GPIO14)
/OUT7: R13.2, R15.2, U1.12 (GPIO12)
/OUT8: R14.2, R16.2, U1.13 (GPIO13)
unnamed: J18.A5 (CC1), R17.2
unnamed: J18.B5 (CC2), R18.2
unnamed: J19.A5 (CC1), R19.2
unnamed: J19.B5 (CC2), R20.2
unnamed: JP1.2 (C), R21.1
unnamed: JP2.2 (C), R22.1
unnamed: JP3.2 (C), R23.1
unnamed: JP4.2 (C), R24.1
unnamed: JP5.2 (C), R25.1
unnamed: JP6.2 (C), R26.1
unnamed: JP7.2 (C), R27.1
unnamed: JP8.2 (C), R28.1
unnamed: JP9.2 (C), R29.1
unnamed: Q1.1 (G), R1.1
unnamed: Q2.1 (G), R2.1
unnamed: Q3.1 (G), R5.1
unnamed: Q4.1 (G), R6.1
unnamed: Q5.1 (G), R9.1
unnamed: Q6.1 (G), R10.1
unnamed: Q7.1 (G), R13.1
unnamed: Q8.1 (G), R14.1

Notes on the sheet:
High Power Output, safe up to 5 Amps
Low Power Output, safe up to 0.5 Amps
NOTE : CC Rp Resistors For 5V/1.5A, use 22k For 5V/3.0A, use 10k
HEAD LIGHT
SPARE
TAIL LIGHT
BRAKE LIGHT
LEFT INDICATOR
RIGHT INDICATOR
72V
GND
12V
NOTE : This block allows setting each input with pull up or pull down
BRAKE

Board: 2 copper layers, 100.0 x 100.0 mm, 106 parts (39 on the bottom side), 51 nets.

Other parts of the board:
kibuzzard-614E1BE6: #G3; label_Cafe_Veloce
kibuzzard-614E1BE6#2: #G1; label_Cafe_Veloce
kibuzzard-614E1CD8: #G4; label_VeloRaptor
kibuzzard-614E1CD8#2: #G2; label_VeloRaptor
kibuzzard-614E1DC4: #G6; label_12V
kibuzzard-614E1DE5: #G5; label_72V
kibuzzard-614E1E6D: #G8; label_GND
kibuzzard-614E1E9D: #G9; label_Brake
kibuzzard-614E1E36: #G7; label_5V
kibuzzard-614E18A2: #G14; label_OUT5
kibuzzard-614E18AA: #G15; label_OUT6
kibuzzard-614E18B2: #G16; label_OUT7
kibuzzard-614E18BA: #G17; label_OUT8
kibuzzard-614E19A5: #G19; label_IN2
kibuzzard-614E19AF: #G20; label_IN3
kibuzzard-614E19B6: #G21; label_IN4
kibuzzard-614E19C0: #G22; label_IN5
kibuzzard-614E19C8: #G23; label_IN6
kibuzzard-614E19D4: #G24; label_IN7
kibuzzard-614E19DD: #G25; label_IN8
kibuzzard-614E188E: #G12; label_OUT3
kibuzzard-614E196C: #G18; label_IN1
kibuzzard-614E1815: #G10; label_OUT1
kibuzzard-614E1883: #G11; label_OUT2
kibuzzard-614E1899: #G13; label_OUT4
